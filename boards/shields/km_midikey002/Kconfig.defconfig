## boards/shields/km_midikey002/Kconfig.defconfig
```kconfig
if SHIELD_KM_MIDIKEY002

config ZMK_KEYBOARD_NAME
    default "km_midikey002"

endif
```
